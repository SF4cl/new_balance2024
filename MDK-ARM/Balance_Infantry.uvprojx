# Keil uVision project Balance_Infantry.uvprojx, settings and files
target Balance_Infantry (6150000::V6.15::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Balance_Infantry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../User/App;../User/Bsp;../User/config;../User/Device/HT04Motor;../User/Device/GO1Motor;../User/Algorithm/EKF;../User/Algorithm/kalman;../User/Algorithm/mahony;../User/Algorithm/PID;../User/controller;../User/Lib;../User/Device/BMI088;../User/Algorithm/VMC;../EC_lib/bsp/bsp_monitor;../EC_lib/bsp/bsp_uart;../EC_lib/device/RM_remote;../EC_lib/Config
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Device
    ../User/Device/BMI088/: BMI088driver.c BMI088Middleware.c
    ../User/Device/HT04Motor/: HT04_drv.c
    ../User/Device/GO1Motor/: GO1_drv.c crc_ccitt.c
  group Bsp
    ../User/Bsp/: bsp_can.c bsp_dwt.c
  group App
    ../User/App/: motor_move.c insTask.c chassisRtask.c chassisLtask.c remoteTask.c observeTask.c
  group Algorithm
    ../User/Algorithm/EKF/: QuaternionEKF.c
    ../User/Algorithm/kalman/: kalman_filter.c
    ../User/Algorithm/mahony/: mahony_filter.c
    ../User/Algorithm/PID/: pid.c
    ../User/Lib/: user_lib.c
    ../User/Algorithm/VMC/: vmcCal.c
  group controller
    ../User/controller/: controller.c
  group EC_lib
    ../EC_lib/bsp/bsp_uart/: bsp_usart.c uart_dma_double.c
    ../EC_lib/device/RM_remote/: RM_remote.c
    ../EC_lib/bsp/bsp_monitor/: bsp_monitor.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
